Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-06-14T15:53:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Interface utilisateur alternative 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 14 15:53:11 2021 * Host: PC-FLORIAN * Database: C:\Users\kevin-D\AppData\Local\Temp\7b90de9d-7b9e-49a0-b0b5-97e01ea0a6a3\3d6d08ee-a399-479c-a8a3-f0fee5009959\ifc * Database version: 5507 * Database creation date: Mon Jun 14 15:53:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 14 15:53:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 14 15:53:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Niveau:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: CMP 250 Combi EasyPlug Boite-Fouet:CMP 250 Combi Boite-Fouet EasyPlug 230/50/1, CMP 250 Combi EasyPlug Boite-Fouet:CMP 250 Combi Boite-Fouet EasyPlug 230/50/1:1012807
In: Level 1
Type - Material: Acier brillant
Type - Pset_ManufacturerTypeInformation - Manufacturer: ROBOT COUPE
Type - Pset_ProvisionForVoid - Width: 200.773 mm; Height: 756.262 mm; Depth: 111.47 mm
Material: Acier brillant, plastique noir, BOUTON ELECTRITE JAUNE, LOGO ROBOT COUPE, Plastique gris foncé
Pset_BuildingElementProxyCommon - Reference: CMP 250 Combi Boite-Fouet EasyPlug 230/50/1; sets with these values: 2
